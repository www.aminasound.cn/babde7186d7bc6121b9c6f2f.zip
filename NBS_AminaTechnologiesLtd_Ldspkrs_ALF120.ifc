Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2020-08-25T09:09:26
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.4.0.0 - Alternate UI 18.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Tue Aug 25 09:09:26 2020* Host: NCL-PI04* Database: C:\Users\BocianP\AppData\Local\Temp\{D1BBF888-5BAC-4F82-900B-EC6C2FC07E5A}\ifc* Database version: 5507* Database creation date: Tue Aug 25 09:09:11 2020* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Tue Aug 25 09:09:25 2020* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Tue Aug 25 09:09:25 2020* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcBuildingElementProxy: ALF120, NBS_AminaTechnologiesLtd_Ldspkrs_ALF120:ALF120:304220
In: Level 0
Type - PredefinedType: USERDEFINED; Classification: Pr_70_75_06_50 (Uniclass2015); Material: NBS_Concept
Type - BOS_General - Author: NBS; BIMObjectName: NBS_AminaTechnologiesLtd_Loudspeakers_ALF120; ManufacturerName: Amina Technologies Ltd; ManufacturerURL: https:/​/​uk.aminasound.com/​; NBSCertification: www.nationalbimlibrary.com/cert/x3fllu2n; NBSDescription: Loudspeakers; NBSReference: 90-70-10/435; ProductInformation: https://uk.aminasound.com/file-directory/product/subwoofers/alf120/datasheet/ALF120_Datasheet.pdf; Revision: n/a; Uniclass2015Title: Loudspeakers; Uniclass2015Code: Pr_70_75_06_50; Uniclass2015Version: Products v1.18; Version: 1
Type - NBS_Data - LoudspeakerSensitivity: 93dB SPL at 1m / 2.83Vrms (half space); RatedImpedance: 6 ohm; PowerHandlingContinuous: 50W; Dispersion: Omnidirectional; EnclosureFormat: Embedded; CableConnectionsType: Push button spring terminals; CableConnectionsCapacity: 14-16 AWG; MaximumPeakInputVoltage: 17.5 V; PortLocations: Front or end firing port locations; PortSlotDimensions: 308 x 14 mm; Weight: 17.5 kg
Type - Pset_AudioVisualApplianceTypeCommon - AudioVolume: 111dB at 1m (half space); MediaSource: n/a; Reference: n/a
Type - Pset_AudioVisualApplianceTypeSpeaker - FrequencyResponse: 27Hz – 120Hz (-6 dB) 48 dB/octave DSP band-pass; Impedence: 6 ohm; SpeakerDriverSize: n/a; SpeakerType: WOOFER
Type - IFC - IfcExportAs: IfcAudioVisualApplianceType; IfcExportType: SPEAKER
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_70_75_06_50:Loudspeakers; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: High performance discreet subwoofer utilizing a highly efficient DTL (distributed transmission line) design, for discreet installation into walls, ceilings or cabinetry; DurationUnit: year; ExpectedLife: n/a; Features: Exceptionally deep and efficient subwoofer. Excellent accuracy, low group delay and minimal distortion, must be used with a DSP amplifier or separate DSP processor; Finish: n/a; Grade: n/a; Manufacturer: sales@aminasound.com; Material: n/a; ModelNumber: ALF120; ModelReference: ALF120; Name: Loudspeakers_ALF120_AminaTechnologiesLtd; NominalWidth: 345 mm; ReplacementCost: n/a; Shape: Rectangular; Size: 1605 x 345 x 118 mm; SustainabilityPerformance: n/a; WarrantyDescription: Manufacturer limited warranty; WarrantyDurationLabor: 0; WarrantyDurationParts: 3; WarrantyDurationUnit: year; WarrantyGuarantorLabor: Installer; WarrantyGuarantorParts: Amina Technologies Ltd
COBie - NominalHeight: 1605 mm; NominalLength: 118 mm; AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcDistributionPort, Port_304220
Description: Flow; FlowDirection: SOURCEANDSINK
